# Keil uVision project Project.uvprojx, settings and files
target HK32F030MF4P6 (6190000::V6.19::ARMCLANG)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.12
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HK32F030M,HK32F030MF4P6
  c include: ..\Source\Libraries\HK32F030M_Lib\inc;..\Source\Libraries\HK32F030M_Lib\src;..\Source\Libraries\CMSIS\CM0\Core;..\Source\Libraries\CMSIS\CM0;..\Source\Libraries\CMSIS\HK32F030M\Include;..\Source\Libraries\CMSIS\HK32F030M\Source;..\Source\User;..\Source\User\led;..\Source\User\AdvanceTim
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group User
    ../Source/User/: hk32f030m_it.c main.c systick_delay.c
    ../Source/User/led/: bsp_led.c
    ../Source/User/AdvanceTim/: bsp_AdvanceTim.c
  group StdPeriph_Driver
    ../Source/Libraries/HK32F030M_Lib/src/: hk32f030m_adc.c hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
  group CMSIS
    ../Source/Libraries/CMSIS/HK32F030M/Source/: system_hk32f030m.c
  group Startup
    ../Source/Libraries/CMSIS/HK32F030M/Source/: KEIL_Startup_hk32f030m.s
  group Doc
    ../Doc/: Readme.txt
